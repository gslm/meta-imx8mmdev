SRCREV = "a68e31b63f864ff71cd4adb40fbc9e1edc75c250"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://devtool-fragment.cfg"

